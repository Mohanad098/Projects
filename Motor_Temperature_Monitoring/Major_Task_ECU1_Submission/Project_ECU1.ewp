# IAR project Project_ECU1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C12GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Button.c Button.h CAN.c CAN.h CAN_Cfg.h CAN_LCfg.c Common_Macros.h Communication.c Communication.h Compiler.h Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_Lcfg.c Dio_Regs.h ECU1_App.c ECU1_App.h main.c MSYS_cfg.h MSYS_Lcfg.c MSYST_Int.h MSYST_Prog.c OS.c OS.h OS_CFG.h OS_LCFG.c Platform_Types.h Port.c Port.h Port_Cfg.h Port_Lcfg.c startup_ewarm.c Std_Types.h tm4c123gh6pm.h
